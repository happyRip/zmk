## app/boards/shields/the_temperance/Kconfig.defconfig
```kconfig
if SHIELD_TEMPERANCE

config ZMK_KEYBOARD_NAME
    default "XIV The Temperance"

config ZMK_USB
    default y

endif
```
